<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_optx.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj; *.o</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt; *.h; *.inc</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp</CppX>
    <nMigrate>0</nMigrate>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>rt-thread</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>12000000</CLKADS>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>0</RunSim>
        <RunTarget>1</RunTarget>
        <RunAbUc>0</RunAbUc>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\build\keil\List\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>18</CpuCode>
      <DebugOpt>
        <uSim>0</uSim>
        <uTrg>1</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>1</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <tRtrace>1</tRtrace>
        <sRSysVw>1</sRSysVw>
        <tRSysVw>1</tRSysVw>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <bEvRecOn>1</bEvRecOn>
        <bSchkAxf>0</bSchkAxf>
        <bTchkAxf>0</bTchkAxf>
        <nTsel>6</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon>STLink\ST-LINKIII-KEIL_SWO.dll</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ST-LINKIII-KEIL_SWO</Key>
          <Name>-U066EFF495056867767053013 -O206 -SF4000 -C0 -A0 -I0 -HNlocalhost -HP7184 -P2 -N00("ARM CoreSight SW-DP") -D00(2BA01477) -L00(0) -TO18 -TC10000000 -TP21 -TDS8007 -TDT0 -TDC1F -TIEFFFFFFFF -TIP8 -FO15 -FD20000000 -FC1000 -FN1 -FF0STM32L4xx_512.FLM -FS08000000 -FL080000 -FP0($$Device:STM32L475VETx$CMSIS\Flash\STM32L4xx_512.FLM)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2CM3</Key>
          <Name>UL2CM3(-S0 -C0 -P0 ) -FN1 -FC1000 -FD20000000 -FF0STM32L4xx_512 -FL080000 -FS08000000 -FP0($$Device:STM32L475VETx$CMSIS\Flash\STM32L4xx_512.FLM)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>JL2CM3</Key>
          <Name>-U -O78 -S2 -ZTIFSpeedSel5000 -A0 -C0 -JU1 -JI127.0.0.1 -JP0 -RST0 -TO18 -TC10000000 -TP21 -TDS8007 -TDT0 -TDC1F -TIEFFFFFFFF -TIP8 -TB1 -TFE0 -FO15 -FD20000000 -FC1000 -FN1 -FF0STM32L4xx_512.FLM -FS08000000 -FL080000 -FP0($$Device:STM32L475VETx$CMSIS\Flash\STM32L4xx_512.FLM)</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <Breakpoint/>
      <Tracepoint>
        <THDelay>0</THDelay>
      </Tracepoint>
      <DebugFlag>
        <trace>0</trace>
        <periodic>0</periodic>
        <aLwin>0</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>0</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
      <bLintAuto>0</bLintAuto>
      <bAutoGenD>0</bAutoGenD>
      <LntExFlags>0</LntExFlags>
      <pMisraName></pMisraName>
      <pszMrule></pszMrule>
      <pSingCmds></pSingCmds>
      <pMultCmds></pMultCmds>
      <pMisraNamep></pMisraNamep>
      <pszMrulep></pszMrulep>
      <pSingCmdsp></pSingCmdsp>
      <pMultCmdsp></pMultCmdsp>
      <DebugDescription>
        <Enable>1</Enable>
        <EnableFlashSeq>0</EnableFlashSeq>
        <EnableLog>0</EnableLog>
        <Protocol>2</Protocol>
        <DbgClock>10000000</DbgClock>
      </DebugDescription>
    </TargetOption>
  </Target>

  <Group>
    <GroupName>Kernel</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>1</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\src\clock.c</PathWithFileName>
      <FilenameWithoutPath>clock.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>2</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\src\components.c</PathWithFileName>
      <FilenameWithoutPath>components.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>3</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\src\cpu.c</PathWithFileName>
      <FilenameWithoutPath>cpu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>4</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\src\device.c</PathWithFileName>
      <FilenameWithoutPath>device.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>5</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\src\idle.c</PathWithFileName>
      <FilenameWithoutPath>idle.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>6</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\src\ipc.c</PathWithFileName>
      <FilenameWithoutPath>ipc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>7</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\src\irq.c</PathWithFileName>
      <FilenameWithoutPath>irq.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>8</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\src\kservice.c</PathWithFileName>
      <FilenameWithoutPath>kservice.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>9</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\src\mem.c</PathWithFileName>
      <FilenameWithoutPath>mem.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>10</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\src\mempool.c</PathWithFileName>
      <FilenameWithoutPath>mempool.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>11</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\src\object.c</PathWithFileName>
      <FilenameWithoutPath>object.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>12</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\src\scheduler.c</PathWithFileName>
      <FilenameWithoutPath>scheduler.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>13</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\src\signal.c</PathWithFileName>
      <FilenameWithoutPath>signal.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>14</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\src\thread.c</PathWithFileName>
      <FilenameWithoutPath>thread.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>15</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\src\timer.c</PathWithFileName>
      <FilenameWithoutPath>timer.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>Applications</GroupName>
<<<<<<< HEAD
    <tvExp>1</tvExp>
=======
    <tvExp>0</tvExp>
>>>>>>> ac6347b... add wifi support
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>16</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>applications\adc_cmd.c</PathWithFileName>
      <FilenameWithoutPath>adc_cmd.c</FilenameWithoutPath>
=======
      <PathWithFileName>applications\main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>17</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>applications\car.c</PathWithFileName>
      <FilenameWithoutPath>car.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
=======
      <PathWithFileName>applications\nrf24l01_init.c</PathWithFileName>
      <FilenameWithoutPath>nrf24l01_init.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>Drivers</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>3</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>18</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>applications\debug_cmd.c</PathWithFileName>
      <FilenameWithoutPath>debug_cmd.c</FilenameWithoutPath>
=======
      <PathWithFileName>board\board.c</PathWithFileName>
      <FilenameWithoutPath>board.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>2</GroupNumber>
=======
      <GroupNumber>3</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>19</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>applications\gimbal_cmd.c</PathWithFileName>
      <FilenameWithoutPath>gimbal_cmd.c</FilenameWithoutPath>
=======
      <PathWithFileName>board\CubeMX_Config\Src\stm32l4xx_hal_msp.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_msp.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>2</GroupNumber>
=======
      <GroupNumber>3</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>20</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>applications\laser_cmd.c</PathWithFileName>
      <FilenameWithoutPath>laser_cmd.c</FilenameWithoutPath>
=======
      <PathWithFileName>board\ports\drv_qspi_flash.c</PathWithFileName>
      <FilenameWithoutPath>drv_qspi_flash.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>2</GroupNumber>
      <FileNumber>21</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>applications\main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
=======
      <GroupNumber>3</GroupNumber>
      <FileNumber>21</FileNumber>
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>libraries\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Source\Templates\arm\startup_stm32l475xx.s</PathWithFileName>
      <FilenameWithoutPath>startup_stm32l475xx.s</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>2</GroupNumber>
=======
      <GroupNumber>3</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>22</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>applications\mobile_cmd.c</PathWithFileName>
      <FilenameWithoutPath>mobile_cmd.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\HAL_Drivers\drv_sdio_adapter.c</PathWithFileName>
      <FilenameWithoutPath>drv_sdio_adapter.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>2</GroupNumber>
=======
      <GroupNumber>3</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>23</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>.\applications\imu_cmd.c</PathWithFileName>
      <FilenameWithoutPath>imu_cmd.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>Drivers</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
=======
      <PathWithFileName>libraries\HAL_Drivers\drv_wlan.c</PathWithFileName>
      <FilenameWithoutPath>drv_wlan.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
>>>>>>> ac6347b... add wifi support
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>24</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>board\board.c</PathWithFileName>
      <FilenameWithoutPath>board.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\HAL_Drivers\drv_gpio.c</PathWithFileName>
      <FilenameWithoutPath>drv_gpio.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>25</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>board\CubeMX_Config\Src\stm32l4xx_hal_msp.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_msp.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\HAL_Drivers\drv_usart.c</PathWithFileName>
      <FilenameWithoutPath>drv_usart.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>26</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>board\ports\sensor_port.c</PathWithFileName>
      <FilenameWithoutPath>sensor_port.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\HAL_Drivers\drv_spi.c</PathWithFileName>
      <FilenameWithoutPath>drv_spi.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>27</FileNumber>
<<<<<<< HEAD
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>libraries\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Source\Templates\arm\startup_stm32l475xx.s</PathWithFileName>
      <FilenameWithoutPath>startup_stm32l475xx.s</FilenameWithoutPath>
=======
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>libraries\HAL_Drivers\drv_qspi.c</PathWithFileName>
      <FilenameWithoutPath>drv_qspi.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>28</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\HAL_Drivers\drv_gpio.c</PathWithFileName>
      <FilenameWithoutPath>drv_gpio.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\HAL_Drivers\drv_flash\drv_flash_l4.c</PathWithFileName>
      <FilenameWithoutPath>drv_flash_l4.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>29</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\HAL_Drivers\drv_usart.c</PathWithFileName>
      <FilenameWithoutPath>drv_usart.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>30</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>libraries\HAL_Drivers\drv_pwm.c</PathWithFileName>
      <FilenameWithoutPath>drv_pwm.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
=======
      <PathWithFileName>libraries\HAL_Drivers\drv_common.c</PathWithFileName>
      <FilenameWithoutPath>drv_common.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>rt_ota</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>30</FileNumber>
      <FileType>4</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>libraries\rt_ota\libs\librt_ota_noalgo_0.1.2_stm32l4_keil.lib</PathWithFileName>
      <FilenameWithoutPath>librt_ota_noalgo_0.1.2_stm32l4_keil.lib</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>STM32_HAL</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>31</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\HAL_Drivers\drv_spi.c</PathWithFileName>
      <FilenameWithoutPath>drv_spi.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Source\Templates\system_stm32l4xx.c</PathWithFileName>
      <FilenameWithoutPath>system_stm32l4xx.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>3</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>32</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\HAL_Drivers\drv_soft_i2c.c</PathWithFileName>
      <FilenameWithoutPath>drv_soft_i2c.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>3</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>33</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\HAL_Drivers\drv_adc.c</PathWithFileName>
      <FilenameWithoutPath>drv_adc.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_comp.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_comp.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>3</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>34</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\HAL_Drivers\drv_common.c</PathWithFileName>
      <FilenameWithoutPath>drv_common.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>modules</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>4</GroupNumber>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_cortex.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_cortex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>35</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>modules\ahrs\ahrs.c</PathWithFileName>
      <FilenameWithoutPath>ahrs.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_crc.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_crc.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>4</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>36</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>modules\ano\ano.c</PathWithFileName>
      <FilenameWithoutPath>ano.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_crc_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_crc_ex.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>4</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>37</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>modules\gimbal\gimbal.c</PathWithFileName>
      <FilenameWithoutPath>gimbal.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_cryp.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_cryp.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>4</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>38</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>modules\imu\imu.c</PathWithFileName>
      <FilenameWithoutPath>imu.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_cryp_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_cryp_ex.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>4</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>39</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>modules\imu\mpu9250.c</PathWithFileName>
      <FilenameWithoutPath>mpu9250.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_dma.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_dma.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>4</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>40</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>modules\imu\mpu9250_port.c</PathWithFileName>
      <FilenameWithoutPath>mpu9250_port.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_dma_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_dma_ex.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>4</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>41</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>modules\laser\laser_launcher.c</PathWithFileName>
      <FilenameWithoutPath>laser_launcher.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_exti.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_exti.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>4</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>42</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>modules\laser\laser_receiver.c</PathWithFileName>
      <FilenameWithoutPath>laser_receiver.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_pwr.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_pwr.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>4</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>43</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>modules\port\ano_port.c</PathWithFileName>
      <FilenameWithoutPath>ano_port.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_pwr_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_pwr_ex.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>4</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>44</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>modules\servo\servo.c</PathWithFileName>
      <FilenameWithoutPath>servo.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>i2c-tools</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>45</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>packages\i2c-tools-latest\src\i2c_utils.cpp</PathWithFileName>
      <FilenameWithoutPath>i2c_utils.cpp</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_rcc.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_rcc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>45</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_rcc_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_rcc_ex.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>46</FileNumber>
<<<<<<< HEAD
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>packages\i2c-tools-latest\src\i2c_tools.cpp</PathWithFileName>
      <FilenameWithoutPath>i2c_tools.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>mpu6xxx</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>6</GroupNumber>
=======
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_rng.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_rng.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>47</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>packages\mpu6xxx-latest\src\mpu6xxx.c</PathWithFileName>
      <FilenameWithoutPath>mpu6xxx.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_gpio.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_gpio.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>6</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>48</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>packages\mpu6xxx-latest\src\sensor_inven_mpu6xxx.c</PathWithFileName>
      <FilenameWithoutPath>sensor_inven_mpu6xxx.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>robots</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>7</GroupNumber>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_uart.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_uart.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>49</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>packages\rt-robot-latest\chassis\chassis.c</PathWithFileName>
      <FilenameWithoutPath>chassis.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_uart_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_uart_ex.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>7</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>50</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>packages\rt-robot-latest\controller\controller.c</PathWithFileName>
      <FilenameWithoutPath>controller.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_usart.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_usart.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>7</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>51</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>packages\rt-robot-latest\controller\inc_pid_controller.c</PathWithFileName>
      <FilenameWithoutPath>inc_pid_controller.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_usart_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_usart_ex.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>7</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>52</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>packages\rt-robot-latest\controller\pos_pid_controller.c</PathWithFileName>
      <FilenameWithoutPath>pos_pid_controller.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_spi.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_spi.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>7</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>53</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>packages\rt-robot-latest\encoder\ab_phase_encoder.c</PathWithFileName>
      <FilenameWithoutPath>ab_phase_encoder.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_spi_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_spi_ex.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>7</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>54</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>packages\rt-robot-latest\encoder\encoder.c</PathWithFileName>
      <FilenameWithoutPath>encoder.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_qspi.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_qspi.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>7</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>55</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>packages\rt-robot-latest\encoder\single_phase_encoder.c</PathWithFileName>
      <FilenameWithoutPath>single_phase_encoder.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_sd.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_sd.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>7</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>56</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>packages\rt-robot-latest\kinematics\kinematics.c</PathWithFileName>
      <FilenameWithoutPath>kinematics.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_sd_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_sd_ex.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>7</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>57</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>packages\rt-robot-latest\motor\dual_pwm_motor.c</PathWithFileName>
      <FilenameWithoutPath>dual_pwm_motor.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_ll_sdmmc.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_ll_sdmmc.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>7</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>58</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>packages\rt-robot-latest\motor\motor.c</PathWithFileName>
      <FilenameWithoutPath>motor.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_flash.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_flash.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>7</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>59</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>packages\rt-robot-latest\motor\single_pwm_motor.c</PathWithFileName>
      <FilenameWithoutPath>single_pwm_motor.c</FilenameWithoutPath>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_flash_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_flash_ex.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>7</GroupNumber>
=======
      <GroupNumber>5</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>60</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>packages\rt-robot-latest\protocol\command.c</PathWithFileName>
      <FilenameWithoutPath>command.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
=======
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_flash_ramfunc.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_flash_ramfunc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>wifi</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>6</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>61</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>packages\rt-robot-latest\protocol\ps2.c</PathWithFileName>
      <FilenameWithoutPath>ps2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>62</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>packages\rt-robot-latest\robot\mobile_robot.c</PathWithFileName>
      <FilenameWithoutPath>mobile_robot.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
=======
      <PathWithFileName>ports\wifi\wifi_config.c</PathWithFileName>
      <FilenameWithoutPath>wifi_config.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>wifi</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>62</FileNumber>
      <FileType>4</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>libraries\wifi\libwifi_6181_0.2.4_armcm4_keil.lib</PathWithFileName>
      <FilenameWithoutPath>libwifi_6181_0.2.4_armcm4_keil.lib</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>EasyFlash</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>8</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>63</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>packages\rt-robot-latest\robot\robot.c</PathWithFileName>
      <FilenameWithoutPath>robot.c</FilenameWithoutPath>
=======
      <PathWithFileName>packages\EasyFlash-v3.3.0\src\easyflash.c</PathWithFileName>
      <FilenameWithoutPath>easyflash.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>7</GroupNumber>
=======
      <GroupNumber>8</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>64</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>packages\rt-robot-latest\wheel\wheel.c</PathWithFileName>
      <FilenameWithoutPath>wheel.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>CORTEX-M4</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
=======
      <PathWithFileName>packages\EasyFlash-v3.3.0\src\ef_cmd.c</PathWithFileName>
      <FilenameWithoutPath>ef_cmd.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
>>>>>>> ac6347b... add wifi support
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>65</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\libcpu\arm\cortex-m4\cpuport.c</PathWithFileName>
      <FilenameWithoutPath>cpuport.c</FilenameWithoutPath>
=======
      <PathWithFileName>packages\EasyFlash-v3.3.0\src\ef_env.c</PathWithFileName>
      <FilenameWithoutPath>ef_env.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>66</FileNumber>
<<<<<<< HEAD
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\libcpu\arm\cortex-m4\context_rvds.S</PathWithFileName>
      <FilenameWithoutPath>context_rvds.S</FilenameWithoutPath>
=======
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>packages\EasyFlash-v3.3.0\src\ef_env_wl.c</PathWithFileName>
      <FilenameWithoutPath>ef_env_wl.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>67</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\libcpu\arm\common\backtrace.c</PathWithFileName>
      <FilenameWithoutPath>backtrace.c</FilenameWithoutPath>
=======
      <PathWithFileName>packages\EasyFlash-v3.3.0\src\ef_iap.c</PathWithFileName>
      <FilenameWithoutPath>ef_iap.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>68</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\libcpu\arm\common\div0.c</PathWithFileName>
      <FilenameWithoutPath>div0.c</FilenameWithoutPath>
=======
      <PathWithFileName>packages\EasyFlash-v3.3.0\src\ef_log.c</PathWithFileName>
      <FilenameWithoutPath>ef_log.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>69</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\libcpu\arm\common\showmem.c</PathWithFileName>
      <FilenameWithoutPath>showmem.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>DeviceDrivers</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>9</GroupNumber>
=======
      <PathWithFileName>packages\EasyFlash-v3.3.0\src\ef_utils.c</PathWithFileName>
      <FilenameWithoutPath>ef_utils.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>70</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\components\drivers\i2c\i2c_core.c</PathWithFileName>
      <FilenameWithoutPath>i2c_core.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
=======
      <PathWithFileName>ports\easyflash\ef_fal_port.c</PathWithFileName>
      <FilenameWithoutPath>ef_fal_port.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>fal</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
>>>>>>> ac6347b... add wifi support
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>71</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\components\drivers\i2c\i2c_dev.c</PathWithFileName>
      <FilenameWithoutPath>i2c_dev.c</FilenameWithoutPath>
=======
      <PathWithFileName>packages\fal-latest\src\fal.c</PathWithFileName>
      <FilenameWithoutPath>fal.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>72</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\components\drivers\i2c\i2c-bit-ops.c</PathWithFileName>
      <FilenameWithoutPath>i2c-bit-ops.c</FilenameWithoutPath>
=======
      <PathWithFileName>packages\fal-latest\src\fal_flash.c</PathWithFileName>
      <FilenameWithoutPath>fal_flash.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>73</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\components\drivers\misc\pin.c</PathWithFileName>
      <FilenameWithoutPath>pin.c</FilenameWithoutPath>
=======
      <PathWithFileName>packages\fal-latest\src\fal_partition.c</PathWithFileName>
      <FilenameWithoutPath>fal_partition.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>74</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\components\drivers\misc\adc.c</PathWithFileName>
      <FilenameWithoutPath>adc.c</FilenameWithoutPath>
=======
      <PathWithFileName>packages\fal-latest\src\fal_rtt.c</PathWithFileName>
      <FilenameWithoutPath>fal_rtt.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>75</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\components\drivers\misc\rt_drv_pwm.c</PathWithFileName>
      <FilenameWithoutPath>rt_drv_pwm.c</FilenameWithoutPath>
=======
      <PathWithFileName>ports\fal\fal_flash_sfud_port.c</PathWithFileName>
      <FilenameWithoutPath>fal_flash_sfud_port.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>76</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\components\drivers\serial\serial.c</PathWithFileName>
      <FilenameWithoutPath>serial.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
=======
      <PathWithFileName>ports\fal\fal_flash_stm32l4_port.c</PathWithFileName>
      <FilenameWithoutPath>fal_flash_stm32l4_port.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>stm32_sdio</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>10</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>77</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\components\drivers\spi\spi_core.c</PathWithFileName>
      <FilenameWithoutPath>spi_core.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
=======
      <PathWithFileName>packages\stm32_sdio-v1.0.2\stm32_sdio.c</PathWithFileName>
      <FilenameWithoutPath>stm32_sdio.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>cpu</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>11</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>78</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\components\drivers\spi\spi_dev.c</PathWithFileName>
      <FilenameWithoutPath>spi_dev.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\libcpu\arm\common\backtrace.c</PathWithFileName>
      <FilenameWithoutPath>backtrace.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>9</GroupNumber>
=======
      <GroupNumber>11</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>79</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\components\drivers\src\completion.c</PathWithFileName>
      <FilenameWithoutPath>completion.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\libcpu\arm\common\div0.c</PathWithFileName>
      <FilenameWithoutPath>div0.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>9</GroupNumber>
=======
      <GroupNumber>11</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>80</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\components\drivers\src\dataqueue.c</PathWithFileName>
      <FilenameWithoutPath>dataqueue.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\libcpu\arm\common\showmem.c</PathWithFileName>
      <FilenameWithoutPath>showmem.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>9</GroupNumber>
=======
      <GroupNumber>11</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>81</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\components\drivers\src\pipe.c</PathWithFileName>
      <FilenameWithoutPath>pipe.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\libcpu\arm\cortex-m4\cpuport.c</PathWithFileName>
      <FilenameWithoutPath>cpuport.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>9</GroupNumber>
      <FileNumber>82</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\drivers\src\ringblk_buf.c</PathWithFileName>
      <FilenameWithoutPath>ringblk_buf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
=======
      <GroupNumber>11</GroupNumber>
      <FileNumber>82</FileNumber>
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\libcpu\arm\cortex-m4\context_rvds.S</PathWithFileName>
      <FilenameWithoutPath>context_rvds.S</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>Filesystem</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>12</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>83</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\components\drivers\src\ringbuffer.c</PathWithFileName>
      <FilenameWithoutPath>ringbuffer.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\dfs\src\dfs.c</PathWithFileName>
      <FilenameWithoutPath>dfs.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>9</GroupNumber>
=======
      <GroupNumber>12</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>84</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\components\drivers\src\waitqueue.c</PathWithFileName>
      <FilenameWithoutPath>waitqueue.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\dfs\src\dfs_file.c</PathWithFileName>
      <FilenameWithoutPath>dfs_file.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>9</GroupNumber>
=======
      <GroupNumber>12</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>85</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\components\drivers\src\workqueue.c</PathWithFileName>
      <FilenameWithoutPath>workqueue.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>Sensors</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>10</GroupNumber>
=======
      <PathWithFileName>rt-thread\components\dfs\src\dfs_fs.c</PathWithFileName>
      <FilenameWithoutPath>dfs_fs.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>86</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\components\drivers\sensors\sensor.c</PathWithFileName>
      <FilenameWithoutPath>sensor.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\dfs\src\dfs_posix.c</PathWithFileName>
      <FilenameWithoutPath>dfs_posix.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>10</GroupNumber>
=======
      <GroupNumber>12</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>87</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\components\drivers\sensors\sensor_cmd.c</PathWithFileName>
      <FilenameWithoutPath>sensor_cmd.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>finsh</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>11</GroupNumber>
=======
      <PathWithFileName>rt-thread\components\dfs\src\poll.c</PathWithFileName>
      <FilenameWithoutPath>poll.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>88</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\components\finsh\shell.c</PathWithFileName>
      <FilenameWithoutPath>shell.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\dfs\src\select.c</PathWithFileName>
      <FilenameWithoutPath>select.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>11</GroupNumber>
=======
      <GroupNumber>12</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>89</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\components\finsh\symbol.c</PathWithFileName>
      <FilenameWithoutPath>symbol.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>11</GroupNumber>
=======
      <PathWithFileName>rt-thread\components\dfs\filesystems\devfs\devfs.c</PathWithFileName>
      <FilenameWithoutPath>devfs.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>DeviceDrivers</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>90</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\components\finsh\cmd.c</PathWithFileName>
      <FilenameWithoutPath>cmd.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\misc\pin.c</PathWithFileName>
      <FilenameWithoutPath>pin.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>11</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>91</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\components\finsh\msh.c</PathWithFileName>
      <FilenameWithoutPath>msh.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\sdio\block_dev.c</PathWithFileName>
      <FilenameWithoutPath>block_dev.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>11</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>92</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\components\finsh\msh_cmd.c</PathWithFileName>
      <FilenameWithoutPath>msh_cmd.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\sdio\mmcsd_core.c</PathWithFileName>
      <FilenameWithoutPath>mmcsd_core.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>11</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>93</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>rt-thread\components\finsh\msh_file.c</PathWithFileName>
      <FilenameWithoutPath>msh_file.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>STM32_HAL</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>12</GroupNumber>
=======
      <PathWithFileName>rt-thread\components\drivers\sdio\sd.c</PathWithFileName>
      <FilenameWithoutPath>sd.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>94</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Source\Templates\system_stm32l4xx.c</PathWithFileName>
      <FilenameWithoutPath>system_stm32l4xx.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\sdio\sdio.c</PathWithFileName>
      <FilenameWithoutPath>sdio.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>95</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\sdio\mmc.c</PathWithFileName>
      <FilenameWithoutPath>mmc.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>96</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_comp.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_comp.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\serial\serial.c</PathWithFileName>
      <FilenameWithoutPath>serial.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>97</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_cortex.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_cortex.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\spi\spi_core.c</PathWithFileName>
      <FilenameWithoutPath>spi_core.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>98</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_crc.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_crc.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\spi\spi_dev.c</PathWithFileName>
      <FilenameWithoutPath>spi_dev.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>99</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_crc_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_crc_ex.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\spi\qspi_core.c</PathWithFileName>
      <FilenameWithoutPath>qspi_core.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>100</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_cryp.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_cryp.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\spi\spi_flash_sfud.c</PathWithFileName>
      <FilenameWithoutPath>spi_flash_sfud.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>101</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_cryp_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_cryp_ex.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\spi\sfud\src\sfud.c</PathWithFileName>
      <FilenameWithoutPath>sfud.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>102</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_dma.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_dma.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\spi\sfud\src\sfud_sfdp.c</PathWithFileName>
      <FilenameWithoutPath>sfud_sfdp.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>103</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_dma_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_dma_ex.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\src\completion.c</PathWithFileName>
      <FilenameWithoutPath>completion.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>104</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_exti.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_exti.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\src\dataqueue.c</PathWithFileName>
      <FilenameWithoutPath>dataqueue.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>105</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_pwr.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_pwr.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\src\pipe.c</PathWithFileName>
      <FilenameWithoutPath>pipe.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>106</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_pwr_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_pwr_ex.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\src\ringblk_buf.c</PathWithFileName>
      <FilenameWithoutPath>ringblk_buf.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>107</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_rcc.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_rcc.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\src\ringbuffer.c</PathWithFileName>
      <FilenameWithoutPath>ringbuffer.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>108</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_rcc_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_rcc_ex.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\src\waitqueue.c</PathWithFileName>
      <FilenameWithoutPath>waitqueue.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>109</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_rng.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_rng.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\src\workqueue.c</PathWithFileName>
      <FilenameWithoutPath>workqueue.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>110</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_gpio.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_gpio.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\wlan\wlan_cfg.c</PathWithFileName>
      <FilenameWithoutPath>wlan_cfg.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>111</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_uart.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_uart.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\wlan\wlan_cmd.c</PathWithFileName>
      <FilenameWithoutPath>wlan_cmd.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>112</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_uart_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_uart_ex.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\wlan\wlan_dev.c</PathWithFileName>
      <FilenameWithoutPath>wlan_dev.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>113</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_usart.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_usart.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\wlan\wlan_lwip.c</PathWithFileName>
      <FilenameWithoutPath>wlan_lwip.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>114</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_usart_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_usart_ex.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\wlan\wlan_mgnt.c</PathWithFileName>
      <FilenameWithoutPath>wlan_mgnt.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>115</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_i2c.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_i2c.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\drivers\wlan\wlan_prot.c</PathWithFileName>
      <FilenameWithoutPath>wlan_prot.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>13</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>116</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_i2c_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_i2c_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
=======
      <PathWithFileName>rt-thread\components\drivers\wlan\wlan_workqueue.c</PathWithFileName>
      <FilenameWithoutPath>wlan_workqueue.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>finsh</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>14</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>117</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_spi.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_spi.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\finsh\shell.c</PathWithFileName>
      <FilenameWithoutPath>shell.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>14</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>118</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_spi_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_spi_ex.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\finsh\symbol.c</PathWithFileName>
      <FilenameWithoutPath>symbol.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>14</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>119</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_qspi.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_qspi.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\finsh\cmd.c</PathWithFileName>
      <FilenameWithoutPath>cmd.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>14</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>120</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_lptim.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_lptim.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\finsh\msh.c</PathWithFileName>
      <FilenameWithoutPath>msh.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>14</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>121</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_tim.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_tim.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\finsh\msh_cmd.c</PathWithFileName>
      <FilenameWithoutPath>msh_cmd.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>14</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>122</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_tim_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_tim_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
=======
      <PathWithFileName>rt-thread\components\finsh\msh_file.c</PathWithFileName>
      <FilenameWithoutPath>msh_file.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>libc</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>15</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>123</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_adc.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_adc.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\libc\compilers\armlibc\libc.c</PathWithFileName>
      <FilenameWithoutPath>libc.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
<<<<<<< HEAD
      <GroupNumber>12</GroupNumber>
=======
      <GroupNumber>15</GroupNumber>
>>>>>>> ac6347b... add wifi support
      <FileNumber>124</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Src\stm32l4xx_hal_adc_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32l4xx_hal_adc_ex.c</FilenameWithoutPath>
=======
      <PathWithFileName>rt-thread\components\libc\compilers\armlibc\mem_std.c</PathWithFileName>
      <FilenameWithoutPath>mem_std.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>125</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\libc\compilers\armlibc\stdio.c</PathWithFileName>
      <FilenameWithoutPath>stdio.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>126</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\libc\compilers\armlibc\stubs.c</PathWithFileName>
      <FilenameWithoutPath>stubs.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>127</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\libc\compilers\armlibc\time.c</PathWithFileName>
      <FilenameWithoutPath>time.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>128</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\libc\compilers\common\gmtime_r.c</PathWithFileName>
      <FilenameWithoutPath>gmtime_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>lwIP</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>129</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\arch\sys_arch.c</PathWithFileName>
      <FilenameWithoutPath>sys_arch.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>130</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\api\api_lib.c</PathWithFileName>
      <FilenameWithoutPath>api_lib.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>131</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\api\api_msg.c</PathWithFileName>
      <FilenameWithoutPath>api_msg.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>132</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\api\err.c</PathWithFileName>
      <FilenameWithoutPath>err.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>133</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\api\netbuf.c</PathWithFileName>
      <FilenameWithoutPath>netbuf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>134</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\api\netdb.c</PathWithFileName>
      <FilenameWithoutPath>netdb.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>135</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\api\netifapi.c</PathWithFileName>
      <FilenameWithoutPath>netifapi.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>136</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\api\sockets.c</PathWithFileName>
      <FilenameWithoutPath>sockets.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>137</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\api\tcpip.c</PathWithFileName>
      <FilenameWithoutPath>tcpip.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>138</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\def.c</PathWithFileName>
      <FilenameWithoutPath>def.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>139</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\dns.c</PathWithFileName>
      <FilenameWithoutPath>dns.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>140</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\inet_chksum.c</PathWithFileName>
      <FilenameWithoutPath>inet_chksum.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>141</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\init.c</PathWithFileName>
      <FilenameWithoutPath>init.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>142</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\ip.c</PathWithFileName>
      <FilenameWithoutPath>ip.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>143</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\memp.c</PathWithFileName>
      <FilenameWithoutPath>memp.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>144</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\netif.c</PathWithFileName>
      <FilenameWithoutPath>netif.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>145</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\pbuf.c</PathWithFileName>
      <FilenameWithoutPath>pbuf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>146</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\raw.c</PathWithFileName>
      <FilenameWithoutPath>raw.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>147</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\stats.c</PathWithFileName>
      <FilenameWithoutPath>stats.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>148</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\sys.c</PathWithFileName>
      <FilenameWithoutPath>sys.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>149</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\tcp.c</PathWithFileName>
      <FilenameWithoutPath>tcp.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>150</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\tcp_in.c</PathWithFileName>
      <FilenameWithoutPath>tcp_in.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>151</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\tcp_out.c</PathWithFileName>
      <FilenameWithoutPath>tcp_out.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>152</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\timeouts.c</PathWithFileName>
      <FilenameWithoutPath>timeouts.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>153</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\udp.c</PathWithFileName>
      <FilenameWithoutPath>udp.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>154</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\netif\ethernet.c</PathWithFileName>
      <FilenameWithoutPath>ethernet.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>155</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\netif\ethernetif.c</PathWithFileName>
      <FilenameWithoutPath>ethernetif.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>156</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\netif\lowpan6.c</PathWithFileName>
      <FilenameWithoutPath>lowpan6.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>157</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\ipv4\autoip.c</PathWithFileName>
      <FilenameWithoutPath>autoip.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>158</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\ipv4\dhcp.c</PathWithFileName>
      <FilenameWithoutPath>dhcp.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>159</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\ipv4\etharp.c</PathWithFileName>
      <FilenameWithoutPath>etharp.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>160</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\ipv4\icmp.c</PathWithFileName>
      <FilenameWithoutPath>icmp.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>161</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\ipv4\igmp.c</PathWithFileName>
      <FilenameWithoutPath>igmp.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>162</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\ipv4\ip4.c</PathWithFileName>
      <FilenameWithoutPath>ip4.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>163</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\ipv4\ip4_addr.c</PathWithFileName>
      <FilenameWithoutPath>ip4_addr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>164</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\core\ipv4\ip4_frag.c</PathWithFileName>
      <FilenameWithoutPath>ip4_frag.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>165</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>rt-thread\components\net\lwip-2.0.2\src\apps\ping\ping.c</PathWithFileName>
      <FilenameWithoutPath>ping.c</FilenameWithoutPath>
>>>>>>> ac6347b... add wifi support
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

</ProjectOpt>
